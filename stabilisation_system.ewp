# IAR project stabilisation_system.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD
  ICCARM.CCIncludePath2: src\system\STM32F10x_StdPeriph_Driver\inc; src\system\CMSIS\CM3\DeviceSupport\ST\STM32F10x; src\board; src\api; src
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: stm32f103cbt.out
  ILINK.IlinkIcfFile: linker\stm32f103xB.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkOutputFile: c.out
  group src
    src/: main.c main.h
    linker/: stm32f103xB.icf
  group src/api
    src/api/: api_baro.c api_baro.h api_body_angle_calculation.c api_body_angle_calculation.h api_cmd.c api_cmd.h api_common.c api_common.h api_CRC.c api_CRC.h api_data_normalising.c api_data_normalising.h api_data_preprocessing.c api_data_preprocessing.h api_end_device.c api_end_device.h api_filters.c api_filters.h api_flash.c api_flash.h api_i2c_acquisition.c api_i2c_acquisition.h api_main_loop.c api_main_loop.h api_nmea.c api_nmea.h api_packet_structure.h api_pid.c api_pid.h api_rx_channels.c api_rx_channels.h MadgwickAHRS.c MadgwickAHRS.h MahonyAHRS.c MahonyAHRS.h
  group src/board
    src/board/: board_acc.c board_acc.h board_adc.c board_adc.h board_baro.c board_baro.h board_dma.c board_dma.h board_drv_adxl345.c board_drv_adxl345.h board_drv_bmp085.c board_drv_bmp085.h board_drv_hmc5883.c board_drv_hmc5883.h board_drv_l3g4200d.c board_drv_l3g4200d.h board_flash.c board_flash.h board_gpio.c board_gpio.h board_gps.c board_gps.h board_gyro.c board_gyro.h board_i2c.c board_i2c.h board_init.c board_init.h board_mag.c board_mag.h board_main_loop.c board_main_loop.h board_NVIC.c board_NVIC.h board_ppm.c board_ppm.h board_pwm.c board_pwm.h board_r_buff.c board_r_buff.h board_state.c board_state.h board_sys_tick.c board_sys_tick.h board_system_init.c board_system_init.h board_system_type.h board_uart.c board_uart.h
  group src/system/CMSIS
    src/system/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group src/system/startup
    src/system/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_md.s
  group src/system/StdPeriph_Driver
    src/system/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
